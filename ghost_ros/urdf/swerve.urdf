Commit message: global refactor from swerve_drive to ghost_ros

File: ghost_ros/urdf/swerve.urdf (robot description, URDF)
Before this commit: robot swerve, 3 links, 8 joints
Links:
- link lidar_link: geometry visual cylinder length=0.0254 radius=${0.06985/2}
